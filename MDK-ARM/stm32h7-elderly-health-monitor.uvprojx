# Keil uVision project stm32h7-elderly-health-monitor.uvprojx, settings and files
target stm32h7-elderly-health-monitor (6240000::V6.24::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32h7-elderly-health-monitor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c misc: -fno-finite-math-only
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../User/PAL;../User/Bsp;../User/App;../User/Middlewares/FreeRTOS;../User/Middlewares/FreeRTOS/include;../User/Middlewares/FreeRTOS/r0p1;../User/Middlewares/LVGL/GUI;../User/Middlewares/LVGL/GUI/lvgl;../User/Middlewares/LVGL/GUI/lvgl/src;../User/Middlewares/LVGL/GUI/lvgl/port;../User/Middlewares/cJSON;../User/Middlewares/LVGL/GUI_APP/ui;../User/Middlewares/LVGL/GUI_APP/ui/components;../User/Middlewares/LVGL/GUI_APP/ui/fonts;../User/Middlewares/LVGL/GUI_APP/ui/images;../User/Middlewares/LVGL/GUI_APP/ui/screens
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c fmc.c i2c.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group User/PAL
    ../User/PAL/: pal_log.c pal_i2c_interface.c ring_buffer.c
  group User/BSP
    ../User/BSP/: bsp_dwt.c bsp_aht30.c bsp_gt911.c bsp_max30102.c bsp_max30102_algorithm.c bsp_at24cxx.c bsp_mq5.c bsp_ds1302.c bsp_a7670c.c bsp_uart_comm.c
    ../User/Bsp/: bsp_lcd.c bsp_bh1750.c bsp_esp8266.c
  group User/APP
    ../User/App/: app_main.c app_lvgl.c app_sensor.c app_rtc_alarm.c app_max30102.c app_alarm_notify.c app_sync_netdata.c app_voice_service.c app_system_monitor.c
  group User/Middlewares/FreeRTOS
    ../User/Middlewares/FreeRTOS/: list.c queue.c tasks.c timers.c heap_4.c event_groups.c stream_buffer.c
    ../User/Middlewares/FreeRTOS/r0p1/: port.c
  group User/Middlewares/LVGL/conf
    ../User/Middlewares/LVGL/GUI/lvgl/: lv_conf.h
  group User/Middlewares/LVGL/port
    ../User/Middlewares/LVGL/GUI/lvgl/port/: lv_port_disp.c lv_port_indev.c
  group User/Middlewares/LVGL/src
    ../User/Middlewares/LVGL/GUI/lvgl/src/: lv_init.c
  group User/Middlewares/LVGL/src/core
    ../User/Middlewares/LVGL/GUI/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group User/Middlewares/LVGL/src/display
    ../User/Middlewares/LVGL/GUI/lvgl/src/display/: lv_display.c
  group User/Middlewares/LVGL/src/draw
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_nema_gfx_path.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group User/Middlewares/LVGL/src/drivers
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/display/drm/: lv_linux_drm.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/evdev/: lv_evdev.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/glfw/: lv_glfw_window.c lv_opengles_debug.c lv_opengles_driver.c lv_opengles_texture.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/qnx/: lv_qnx.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_shell.c lv_wl_shm.c lv_wl_touch.c lv_wl_window.c lv_wl_window_decorations.c lv_wl_xdg_shell.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
  group User/Middlewares/LVGL/src/font
    ../User/Middlewares/LVGL/GUI/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group User/Middlewares/LVGL/src/indev
    ../User/Middlewares/LVGL/GUI/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group User/Middlewares/LVGL/src/layouts
    ../User/Middlewares/LVGL/GUI/lvgl/src/layouts/flex/: lv_flex.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/layouts/grid/: lv_grid.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/layouts/: lv_layout.c
  group User/Middlewares/LVGL/src/libs
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/bmp/: lv_bmp.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/libpng/: lv_libpng.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/lz4/: lz4.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/rle/: lv_rle.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group User/Middlewares/LVGL/src/misc
    ../User/Middlewares/LVGL/GUI/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group User/Middlewares/LVGL/src/osal
    ../User/Middlewares/LVGL/GUI/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group User/Middlewares/LVGL/src/others
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/gridnav/: lv_gridnav.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/imgfont/: lv_imgfont.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/monkey/: lv_monkey.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/observer/: lv_observer.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/snapshot/: lv_snapshot.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/sysmon/: lv_sysmon.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_event_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_parser.c lv_xml_style.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
  group User/Middlewares/LVGL/src/stdlib
    ../User/Middlewares/LVGL/GUI/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/stdlib/: lv_mem.c
  group User/Middlewares/LVGL/src/themes
    ../User/Middlewares/LVGL/GUI/lvgl/src/themes/default/: lv_theme_default.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/themes/mono/: lv_theme_mono.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/themes/simple/: lv_theme_simple.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/themes/: lv_theme.c
  group User/Middlewares/LVGL/src/tick
    ../User/Middlewares/LVGL/GUI/lvgl/src/tick/: lv_tick.c
  group User/Middlewares/LVGL/src/widgets
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/animimage/: lv_animimage.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/arc/: lv_arc.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/bar/: lv_bar.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/button/: lv_button.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/canvas/: lv_canvas.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/chart/: lv_chart.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/image/: lv_image.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/label/: lv_label.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/led/: lv_led.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/line/: lv_line.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/list/: lv_list.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/lottie/: lv_lottie.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/menu/: lv_menu.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/roller/: lv_roller.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/scale/: lv_scale.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/slider/: lv_slider.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/span/: lv_span.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/spinner/: lv_spinner.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/switch/: lv_switch.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/table/: lv_table.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/tabview/: lv_tabview.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/textarea/: lv_textarea.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/tileview/: lv_tileview.c
    ../User/Middlewares/LVGL/GUI/lvgl/src/widgets/win/: lv_win.c
  group User/Middlewares/LVGL/ui
    ../User/Middlewares/LVGL/GUI_APP/ui/: ui.c ui_helpers.c
    ../User/Middlewares/LVGL/GUI_APP/ui/components/: ui_comp_hook.c ui_comp.c ui_comp_uilabeltime.c
    ../User/Middlewares/LVGL/GUI_APP/ui/screens/: ui_Screen1.c
    ../User/Middlewares/LVGL/GUI_APP/ui/fonts/: ui_font_AlibabaPuHuiTiMedium.c ui_font_AlibabaPuHuiTi32.c
    ../User/Middlewares/LVGL/GUI_APP/ui/images/: ui_img_temp_png.c
  group User/Middlewares/cJSON
    ../User/Middlewares/cJSON/: cJSON.c
software components: CMSIS:CORE 6.2.0
